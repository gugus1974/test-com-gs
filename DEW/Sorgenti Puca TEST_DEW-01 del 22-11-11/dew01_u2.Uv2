### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0002 // Tools: '166/167'

Group (Source Group 1)

File 1,1,<SOURCE\TSTDEW01.C><TSTDEW01.C>
File 1,1,<SOURCE\TSTFLASH.C><TSTFLASH.C>
File 1,1,<SOURCE\TSTPIO.C><TSTPIO.C>
File 1,1,<SOURCE\TSTADC.C><TSTADC.C>
File 1,1,<SOURCE\TSTAUX.C><TSTAUX.C>
File 1,1,<SOURCE\TSTMVB.C><TSTMVB.C>
File 1,1,<SOURCE\DRVUART.C><DRVUART.C>
File 1,4,<..\..\Libdew\Obj\Libdew.LIB><Libdew.LIB>


Options 1,0,0  // Target 'Target 1'
 Device (C167CS-LM)
 Vendor (Infineon)
 Cpu (IRAM (0xF200 - 0xFDFF) XRAM(0xE000-0xE7FF) XRAM2 (0xC000-0xD7FF) ICAN(0xE800-0xEFFF) CLOCK(25000000) MOD167)
 Rgf ()
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg ()
 TgStat=0
 OutDir (.\Obj\)
 OutName (tstdew01_u2)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=0
 LstDir (.\source\)
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 Model=6
 RTOS=0
 nHold=6
 iHold=65535
 sHold=65535
 bHold=65535
 MOD167=1
 UseOnChipRom=0
 UseOnchipXCAN=0
 UseOnchipXRAM2=0
 NearRam=0
 NearRom=0
 ExtMem 0 0,0,0
 ExtMem 1 0,0,0
 ExtMem 2 0,0,0
 ExtMem 3 0,0,0
 ExtMem 4 0,0,0
 ExtMem 5 0,0,0
 Optimize=6
 SpeedSize=1
 RegColor=0
 Static=0
 WarningLev=0
 Alias=0
 Order=0
 UnsignedChar=0
 NoDppSave=1
 Float64=0
 SaveUsr=0
 cMisc (MOD167 HL(Near 1024) )
 Define ()
 Undefine ()
 INCC6 (c:\sw_dew\libdew\header;c:\sw_dew\dew01\tstdew\header)
 MPL=1
 CASE=0
 aMisc (MOD167)
 aSet ()
 aReset ()
 INCA6 (c:\sw_dew\libdew\header;c:\sw_dew\dew01\tstdew\header)
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 useLinkFile=0
 LnkFile ()
 LinkOnly=0
 UseTargSet=0
 DppUse=1
 nDataSel=0
 nConstSel=3
 NearDataStr (0-0xBFFF)
 NearConstStr (0xC000-0xEFFF)
 CinitTab ()
 IntVectAddr (00H)
 lWarnLev=2
 lDisWarn ()
 lAssign ()
 lRegbank ()
 lReserve ()
 lMisc ()
 lClasses (ICODE(0x10000-0xFFFFF),NCODE(0x10000-0xFFFFF),FCODE(0x10000-0xFFFFF),NCONST(0xC000-0xEFFF), HCONST(0x10000-0x3FFFF),NDATA(0x8000-0xBFFF),NDATA0(0x200-0xBFFF),HDATA(0x10000-0xFFFFF),HDATA0(0x10000-0xFFFFF),XDATA(0x10000-0xFFFFF),XDATA0(0x10000-0xFFFFF))
 lSect (?C_INITSEC(0x10000),?C_CLRMEMSEC)
  OPTDL (S166.DLL)()(D167.DLL)(-p167CS)(S166.DLL)()(T167.DLL)(-p167CS)
  OPTDBG 509,0,()()()()()()()()()() ()()()()
EndOpt

